<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>env_sim_server_debug_outputs</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>channel_gain_linear</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>.01</value></param>
<param><key>option</key><value>channel_gain_linear</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>env_time_frac_s</value></param>
<param><key>value</key><value>now-int(now)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>env_time_int_s</value></param>
<param><key>value</key><value>int(now)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eth0_addr</value></param>
<param><key>value</key><value>temp_py_mod.get_debug_ip()</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>host</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>192.168.40.2</value></param>
<param><key>option</key><value>host_ip</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>increment_usrp_address_bool</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>True</value></param>
<param><key>option</key><value>increment_usrp_address</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>bool</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>noise_amp</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>.001</value></param>
<param><key>option</key><value>noise_amp</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>now</value></param>
<param><key>value</key><value>time.time()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_nodes</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>port_num_base</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>52001</value></param>
<param><key>option</key><value>port_num_base</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>option</key><value>samp_rate</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrp_ip_base</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>101</value></param>
<param><key>option</key><value>usrp_ip_base</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>int</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_ip_list</value></param>
<param><key>value</key><value>temp_py_mod.make_usrp_ip_list(increment_usrp_address_bool, usrp_ip_prefix_str, usrp_ip_base, num_nodes)</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>usrp_ip_prefix_str</value></param>
<param><key>config_file</key><value>config_file</value></param>
<param><key>value</key><value>192.168.40.</value></param>
<param><key>option</key><value>usrp_ip_prefix</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>string</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>zmq_base_addr</value></param>
<param><key>value</key><value>"tcp://" + eth0_addr + ":"</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise_amp</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0</value></param>
<param><key>hi</key><value>1.0</value></param>
<param><key>lo</key><value>-1.0</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_0</value></param>
<param><key>hi</key><value>1.0</value></param>
<param><key>lo</key><value>-1.0</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_0_0</value></param>
<param><key>hi</key><value>1.0</value></param>
<param><key>lo</key><value>-1.0</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_0_1</value></param>
<param><key>hi</key><value>1.0</value></param>
<param><key>lo</key><value>-1.0</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_1</value></param>
<param><key>hi</key><value>1.0</value></param>
<param><key>lo</key><value>-1.0</value></param>
</block>
<block>
<key>analog_rail_ff</key>
<param><key>id</key><value>analog_rail_ff_0_2</value></param>
<param><key>hi</key><value>1.0</value></param>
<param><key>lo</key><value>-1.0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>4</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0_1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>channel_gain_linear</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0_0</value></param>
<param><key>const</key><value>channel_gain_linear</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>blocks_probe_rate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>mintime</key><value>5000.0</value></param>
<param><key>alpha</key><value>0.15</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>2048</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>channels_sro_model</key>
<param><key>id</key><value>channels_sro_model_0</value></param>
<param><key>maxdev</key><value>1e3</value></param>
<param><key>stdev</key><value>0.01</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>channels_sro_model</key>
<param><key>id</key><value>channels_sro_model_0_0</value></param>
<param><key>maxdev</key><value>1e3</value></param>
<param><key>stdev</key><value>0.01</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>seed</key><value>1</value></param>
</block>
<block>
<key>channels_sro_model</key>
<param><key>id</key><value>channels_sro_model_0_1</value></param>
<param><key>maxdev</key><value>1e3</value></param>
<param><key>stdev</key><value>0.01</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>seed</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>config_file</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>envsim.ini</value></param>
</block>
<block>
<key>envsim_socket_meta_pdu</key>
<param><key>id</key><value>envsim_socket_meta_pdu_0_0_0</value></param>
<param><key>host</key><value>usrp_ip_list[1]</value></param>
<param><key>mtu</key><value>40000</value></param>
<param><key>port</key><value>str(port_num_base+1)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>envsim_socket_meta_pdu</key>
<param><key>id</key><value>envsim_socket_meta_pdu_0_1_0_0</value></param>
<param><key>host</key><value>usrp_ip_list[3]</value></param>
<param><key>mtu</key><value>40000</value></param>
<param><key>port</key><value>str(port_num_base+3)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>envsim_socket_meta_pdu</key>
<param><key>id</key><value>envsim_socket_meta_pdu_0_1_1_0</value></param>
<param><key>host</key><value>usrp_ip_list[4]</value></param>
<param><key>mtu</key><value>40000</value></param>
<param><key>port</key><value>str(port_num_base+4)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>envsim_socket_meta_pdu</key>
<param><key>id</key><value>envsim_socket_meta_pdu_0_1_2_0</value></param>
<param><key>host</key><value>usrp_ip_list[5]</value></param>
<param><key>mtu</key><value>40000</value></param>
<param><key>port</key><value>str(port_num_base+5)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>envsim_socket_meta_pdu</key>
<param><key>id</key><value>envsim_socket_meta_pdu_0_1_3</value></param>
<param><key>host</key><value>usrp_ip_list[2]</value></param>
<param><key>mtu</key><value>40000</value></param>
<param><key>port</key><value>str(port_num_base+2)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>envsim_socket_meta_pdu</key>
<param><key>id</key><value>envsim_socket_meta_pdu_0_2</value></param>
<param><key>host</key><value>usrp_ip_list[0]</value></param>
<param><key>mtu</key><value>40000</value></param>
<param><key>port</key><value>str(port_num_base+0)</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>envsim_zmq_envsim_source</key>
<param><key>id</key><value>envsim_zmq_envsim_source_0</value></param>
<param><key>address</key><value>"tcp://"+ usrp_ip_list[5] + ":" +  str(port_num_base+5)</value></param>
<param><key>hwm</key><value>100</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>start_time_frac_s</key><value>env_time_frac_s</value></param>
<param><key>start_time_int_s</key><value>env_time_int_s</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>envsim_zmq_envsim_source</key>
<param><key>id</key><value>envsim_zmq_envsim_source_0_0</value></param>
<param><key>address</key><value>"tcp://"+ usrp_ip_list[4] + ":" +  str(port_num_base+4)</value></param>
<param><key>hwm</key><value>100</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>start_time_frac_s</key><value>env_time_frac_s</value></param>
<param><key>start_time_int_s</key><value>env_time_int_s</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>envsim_zmq_envsim_source</key>
<param><key>id</key><value>envsim_zmq_envsim_source_0_1</value></param>
<param><key>address</key><value>"tcp://"+ usrp_ip_list[3] + ":" +  str(port_num_base+3)</value></param>
<param><key>hwm</key><value>100</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>start_time_frac_s</key><value>env_time_frac_s</value></param>
<param><key>start_time_int_s</key><value>env_time_int_s</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>envsim_zmq_envsim_source</key>
<param><key>id</key><value>envsim_zmq_envsim_source_0_2</value></param>
<param><key>address</key><value>"tcp://"+ usrp_ip_list[0] + ":" +  str(port_num_base+0)</value></param>
<param><key>hwm</key><value>100</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>start_time_frac_s</key><value>env_time_frac_s</value></param>
<param><key>start_time_int_s</key><value>env_time_int_s</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>envsim_zmq_envsim_source</key>
<param><key>id</key><value>envsim_zmq_envsim_source_0_2_0</value></param>
<param><key>address</key><value>"tcp://"+ usrp_ip_list[1] + ":" +  str(port_num_base+1)</value></param>
<param><key>hwm</key><value>100</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>start_time_frac_s</key><value>env_time_frac_s</value></param>
<param><key>start_time_int_s</key><value>env_time_int_s</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>envsim_zmq_envsim_source</key>
<param><key>id</key><value>envsim_zmq_envsim_source_0_2_0_0</value></param>
<param><key>address</key><value>"tcp://"+ usrp_ip_list[2] + ":" +  str(port_num_base+2)</value></param>
<param><key>hwm</key><value>100</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>start_time_frac_s</key><value>env_time_frac_s</value></param>
<param><key>start_time_int_s</key><value>env_time_int_s</value></param>
<param><key>timeout</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import netifaces as ni</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>temp_py_mod</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph

def make_usrp_ip_list(increment_address, ip_prefix, ip_base, num_nodes):
    '''
    Try to make it sane to allow people to use either fixed or incrementing IPs.
    Note: using 127.0.0.1 for both socket_meta_pdu servers and clients will
    result in conflicts. Consider using eth0 IP instead for the servers.

    IP prefix must be of the form "192.168.40."

    IP base is an int.

    Resulting list will be ip_prefix + "{}".format(ip_base +i)
    '''
    if increment_address:
        return [ip_prefix + "{}".format(ip_base +i) for i in range(num_nodes)]
    else:
        return [ip_prefix + "{}".format(ip_base) for i in range(num_nodes)]


import netifaces as ni

def get_debug_ip():
    '''
    This is used to allow people to autogenerate python from GNURadio Companion
    for the debug flowgraph in the case that their host system does not have an "eth0" interface.
    '''

    if u"eth0" in ni.interfaces():
        debug_ip = str(ni.ifaddresses("eth0")[ni.AF_INET][0]['addr'].decode('utf-8'))
    else:
        debug_ip = "10.0.0.0"

    return debug_ip
</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>time_import</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0</value></param>
<param><key>address</key><value>zmq_base_addr+str(port_num_base+0)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0</value></param>
<param><key>address</key><value>zmq_base_addr+str(port_num_base+1)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0_0</value></param>
<param><key>address</key><value>zmq_base_addr+str(port_num_base+2)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0_0_0</value></param>
<param><key>address</key><value>zmq_base_addr+str(port_num_base+3)</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_push_sink</key>
<param><key>id</key><value>zeromq_push_sink_0_0_0_0_0</value></param>
<param><key>address</key><value>zmq_base_addr+str(port_num_base+4)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_0_1</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_1</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_rail_ff_0_2</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_1</source_block_id><sink_block_id>blocks_multiply_const_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>analog_rail_ff_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>analog_rail_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>analog_rail_ff_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_0</source_block_id><sink_block_id>analog_rail_ff_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_1</source_block_id><sink_block_id>analog_rail_ff_0_2</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0_1</source_block_id><sink_block_id>analog_rail_ff_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>channels_sro_model_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>channels_sro_model_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1</source_block_id><sink_block_id>channels_sro_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_probe_rate_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>rate</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>zeromq_push_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>zeromq_push_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>envsim_socket_meta_pdu_0_1_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>envsim_socket_meta_pdu_0_1_1_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>envsim_socket_meta_pdu_0_1_2_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>envsim_socket_meta_pdu_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>envsim_socket_meta_pdu_0_1_3</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>envsim_socket_meta_pdu_0_2</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_probe_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_sro_model_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>channels_sro_model_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>channels_sro_model_0_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_1</source_block_id><sink_block_id>blocks_complex_to_float_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_2</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_2</source_block_id><sink_block_id>zeromq_push_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_2_0</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_2_0</source_block_id><sink_block_id>zeromq_push_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_2_0_0</source_block_id><sink_block_id>blocks_add_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>envsim_zmq_envsim_source_0_2_0_0</source_block_id><sink_block_id>zeromq_push_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
